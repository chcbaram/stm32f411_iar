# IAR project stm32f411_fw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE
  ICCARM.CCIncludePath2: src; src\ap; src\bsp; src\common; src\common\core; src\common\hw\include; src\hw; src\lib; src\lib\cube_f411\Drivers\CMSIS\Device\ST\STM32F4xx\Include; src\lib\cube_f411\Drivers\CMSIS\Include; src\lib\cube_f411\Drivers\STM32F4xx_HAL_Driver\Inc; src\lib\cube_f411\Core\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\lib\cube_f411\EWARM\stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group src
    src/: main.c main.h
  group src/ap
    src/ap/: ap.c ap.h
  group src/bsp
    src/bsp/: bsp.c bsp.h
    src/lib/cube_f411/Core/Inc/: stm32f4xx_hal_conf.h stm32f4xx_it.h
    src/lib/cube_f411/Core/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group src/bsp/startup
    src/lib/cube_f411/EWARM/: startup_stm32f411xe.s
  group src/common
    src/common/: def.h
    src/lib/cube_f411/Core/: Src
  group src/common/core
    src/common/core/: qbuffer.c qbuffer.h
  group src/common/hw/include
    src/common/hw/include/: led.h
  group src/hw
    src/hw/: hw.c hw.h hw_def.h
  group src/hw/driver
    src/hw/driver/: led.c
  group src/lib/cube/CMSIS
    src/lib/cube_f411/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f411xe.h stm32f4xx.h system_stm32f4xx.h
  group src/lib/cube/STM32F4xx_HAL_Driver/Inc
    src/lib/cube_f411/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_exti.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h
  group src/lib/cube/STM32F4xx_HAL_Driver/Src
    src/lib/cube_f411/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
